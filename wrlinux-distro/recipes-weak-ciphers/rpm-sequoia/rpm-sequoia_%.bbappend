RPM-SEQUOIA_INC_WRLINUX = ""
RPM-SEQUOIA_INC_WRLINUX:osv-wrlinux = "rpm-sequoia_wrlinux.inc"
require ${RPM-SEQUOIA_INC_WRLINUX}

# nmap has been removed from the supported packages list to avoid IP issues
RDEPENDS:${PN}-ptest:remove = "nmap"
